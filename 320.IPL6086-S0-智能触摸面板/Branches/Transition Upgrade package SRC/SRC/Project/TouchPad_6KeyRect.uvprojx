# Keil uVision project TouchPad_6KeyRect.uvprojx, settings and files
target STM32L151 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IPL6086-S0_B_V9999 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L1XX_MD,STM32L151
  c include: ..\Core\startup;..\Core;..\Lib_code\App;..\Lib_code\SysHard\inc;..\Lib_code\SysLib\inc;..\Lib_code\SysPower;..\User\Driver\IIC;..\User\Driver\OLED;..\User\Driver\ShakeMotor;..\User\Driver\USART2;..\User\Driver\WTC6216;..\User\Key;..\User\TouchPad_AirCondition;..\User\IWDG;..\User\Driver\74HC595;..\User\Driver\Queue;..\Lib_code\Filter\inc;..\User\Driver\TIMx
  memory RVCT4: ROM 0x800c400 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group StartUp
    ../Core/startup/: startup_stm32l1xx_md.s
    ../Core/: system_stm32l1xx.c
  group SysLib
    ../Lib_code/SysLib/: BestFuLib.c CMDProcess.c Command.c CRC.c Delay.c EEPROM.c FaultManage.c Fifo.c FlashAttr.c LinkScanFifo.c Linksimplest.c Linksrc.c LinkWRDC.c MsgPackage.c Object.c Scene&Group.c Sign433.c Sign433Attr.c SysExeAttr.c SysTestAttr.c Thread.c UnitShare_Attr.c Updata.c Upload.c UserData.c UserDataDownload.c
  group SysHard
    ../Lib_code/SysHard/: DeviceReset.c Flash.c Gpio.c I2C.C Instruct.c Program.c SI4432.c SPI.c Sys.c SysHard.c SysTick.c Test.c Usart.c WDG.c FlashSizeFlag.c
    ../Lib_code/SysPower/: ADC.c Battery.c BatteryExeAttr.c LowPower.c
    ../Lib_code/Filter/: ImportFilter.c
  group APP
    ../Lib_code/App/: main.c UnitCfg.c
  group Drive
    ../User/Driver/IIC/: IIC.c
    ../User/Driver/OLED/: OLED.c TouchPadPic.c
    ../User/Driver/WTC6216/: WTC6216.c
    ../User/IWDG/: iwdg.c
    ../User/Driver/74HC595/: ShowLED.c
    ../User/Driver/Queue/: Queue.c
    ../User/Driver/TIMx/: TIMx.c
  group Unit
    ../User/Key/: Key.c
  group Attr
    ../User/TouchPad_AirCondition/: KeyExeAttr.c
  group Readme
    ../: Readme.txt
